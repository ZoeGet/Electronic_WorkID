
#include "display_chinese.h"
#include "st7735.h"

const unsigned char ling[DISPLAY_CHINESE_COUNT][DISPLAY_CHINESE_BYTES]=
{
    {0x40,0x10,0x40,0x18,0x7F,0xF0,0x49,0x10,0x49,0x20,0x7F,0xFF,0x42,0x20,0x44,0x80,0x08,0x90,0x30,0x88,0xC4,0x84,0x33,0x8B,0x08,0xB0,0x04,0xC0,0x02,0x00,0x00,0x00},/*"聆",0*/
    {0x00,0x01,0x00,0x06,0x7F,0xF8,0x40,0x00,0x40,0x44,0x5F,0x54,0x75,0x54,0x55,0x7C,0x55,0x54,0x5F,0x54,0x40,0x44,0x40,0x00,0x7F,0xFC,0x00,0x02,0x00,0x1F,0x00,0x00},/*"凰",1*/
    {0x24,0x10,0x24,0x60,0x25,0x80,0x7F,0xFF,0xC5,0x00,0x44,0x80,0x00,0x20,0x44,0x20,0x33,0x20,0x00,0x20,0x00,0x20,0xFF,0xFF,0x00,0x40,0x00,0x40,0x00,0x40,0x00,0x00},/*"科",2*/
    {0x08,0x20,0x08,0x22,0x08,0x41,0xFF,0xFE,0x08,0x80,0x09,0x01,0x10,0x01,0x11,0x02,0x11,0xC2,0x11,0x34,0xFF,0x08,0x11,0x14,0x11,0x62,0x11,0x81,0x10,0x01,0x00,0x00},/*"技",3*/
    {0x08,0x00,0x29,0x00,0xCA,0x00,0x4C,0xFF,0x78,0x92,0x4C,0x92,0x4A,0x92,0x08,0x92,0x00,0x92,0x7E,0x92,0x42,0x92,0x42,0xFF,0x42,0x00,0x7E,0x00,0x00,0x00,0x00,0x00},/*"智",4*/
    {0x10,0x00,0x33,0xFF,0x52,0x48,0x92,0x48,0x12,0x4A,0x52,0x49,0x33,0xFE,0x18,0x00,0x00,0x00,0xFE,0x7E,0x11,0x11,0x11,0x11,0x21,0x21,0x41,0x41,0x07,0x07,0x00,0x00},/*"能",5*/
    {0x00,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x3F,0xFC,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x00,0x04,0x00,0x00},/*"工",6*/
    {0x00,0x01,0x7F,0xFE,0x04,0x80,0x04,0x80,0xFC,0xFF,0x04,0x00,0x00,0x10,0x3F,0xB0,0x64,0xD0,0xA5,0x90,0x3E,0x90,0x24,0xFF,0x24,0x90,0x3F,0x90,0x00,0x10,0x00,0x00},/*"牌",7*/

    {0x08,0x02,0x08,0x44,0x0F,0xA8,0xF8,0x10,0x08,0x68,0x0F,0x84,0x02,0x02,0x3C,0x42,0x08,0x42,0x08,0x42,0xFF,0xFE,0x08,0x42,0x08,0x42,0x08,0x42,0x00,0x02,0x00,0x00},/*"姓",0*/
    {0x00,0x20,0x04,0x20,0x04,0x20,0x08,0x40,0x10,0x7F,0x28,0xC2,0xE6,0xC2,0x21,0x42,0x22,0x42,0x24,0x42,0x28,0x42,0x30,0x42,0x00,0x7F,0x00,0x00,0x00,0x00,0x00,0x00},/*"名",1*/

    {0x00,0x00,0x00,0x00,0x77,0xFF,0x14,0x00,0x14,0x04,0x14,0x88,0x14,0x50,0xF4,0x20,0x14,0x50,0x15,0x88,0x14,0x02,0x14,0x01,0x77,0xFE,0x00,0x00,0x00,0x00,0x00,0x00},/*"岗",2*/
    {0x00,0x80,0x01,0x00,0x06,0x00,0x1F,0xFF,0xE0,0x02,0x08,0x02,0x09,0x82,0x08,0x7A,0x88,0x02,0x68,0x02,0x08,0x0E,0x08,0x72,0x0B,0x82,0x08,0x02,0x00,0x02,0x00,0x00},/*"位",3*/

    {0x02,0x00,0x22,0x00,0x2A,0x7E,0xA6,0x44,0x62,0x44,0x22,0x44,0x26,0x44,0x2A,0x7E,0x22,0x00,0x02,0x00,0x7F,0xFF,0x40,0x10,0x44,0x08,0x5B,0x10,0x60,0xE0,0x00,0x00},/*"部",4*/
    {0x00,0x00,0x1F,0xFF,0x80,0x00,0x60,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x40,0x00,0x40,0x00,0x40,0x00,0x40,0x00,0x40,0x02,0x40,0x01,0x7F,0xFE,0x00,0x00,0x00,0x00},/*"门",5*/

    {0x00,0x10,0x00,0x20,0x00,0xC0,0x07,0x00,0x00,0x00,0x00,0x02,0x00,0x01,0xFF,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x00,0x02,0x00,0x01,0x80,0x00,0x70,0x00,0x00},/*"小",6*/

    {0x01,0x00,0x01,0x02,0x02,0x02,0x04,0x22,0x0A,0x22,0x12,0x22,0x22,0x22,0xC3,0xFE,0x22,0x22,0x12,0x22,0x0A,0x22,0x04,0x22,0x02,0x02,0x01,0x02,0x01,0x00,0x00,0x00},/*"全",7*/
    {0x08,0x20,0x08,0xC0,0x0B,0x00,0xFF,0xFF,0x09,0x00,0x08,0x80,0x00,0x02,0x09,0x02,0x09,0x04,0xFF,0xC8,0x09,0x30,0x92,0x28,0x52,0x44,0x12,0x82,0x02,0x1F,0x00,0x00},/*"栈",8*/
    {0x00,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x3F,0xFC,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x20,0x04,0x00,0x04,0x00,0x00},/*"工",9*/
    {0x24,0x10,0x24,0x60,0x25,0x80,0x7F,0xFF,0xC4,0x80,0x44,0x60,0x00,0x02,0x7C,0x92,0x44,0x92,0x44,0x92,0x44,0xFE,0x44,0x92,0x44,0x92,0x7C,0x92,0x00,0x82,0x00,0x00},/*"程",10*/
    {0x00,0x00,0x3F,0xE1,0x00,0x02,0x00,0x0C,0xFF,0xF0,0x00,0x00,0x40,0x00,0x47,0xF8,0x44,0x00,0x44,0x00,0x7F,0xFF,0x44,0x10,0x44,0x08,0x47,0xF0,0x40,0x00,0x00,0x00},/*"师",11*/

    {0x10,0x10,0x13,0x18,0x1D,0x10,0xF1,0x10,0x17,0xFF,0x11,0x20,0x11,0x21,0x02,0x02,0x0C,0x0C,0xF0,0x70,0x13,0x80,0x10,0x70,0x14,0x0C,0x18,0x02,0x00,0x01,0x00,0x00},/*"软",12*/
    {0x20,0x40,0x21,0x80,0x27,0xFE,0x3A,0x08,0x22,0x08,0x23,0xFC,0x00,0x01,0x4F,0xF1,0x49,0x2A,0x49,0x24,0x7F,0xFA,0x49,0x22,0x49,0x21,0x4F,0xE1,0x40,0x01,0x00,0x00},/*"硬",13*/
    {0x00,0x80,0x01,0x00,0x06,0x00,0x1F,0xFF,0xE0,0x00,0x01,0x40,0x06,0x40,0x38,0x40,0x08,0x40,0x08,0x40,0xFF,0xFF,0x08,0x40,0x08,0x40,0x08,0x40,0x00,0x40,0x00,0x00},/*"件",14*/
    {0x01,0x00,0x41,0x01,0x41,0x02,0x41,0x0C,0x7F,0xF0,0x41,0x00,0x41,0x00,0x41,0x00,0x41,0x00,0x41,0x00,0x7F,0xFF,0x41,0x00,0x41,0x00,0x41,0x00,0x01,0x00,0x00,0x00},/*"开",15*/
    {0x00,0x00,0x00,0x04,0x18,0x08,0x68,0x31,0x08,0xC1,0x0B,0x01,0x1D,0x82,0xE9,0x62,0x09,0x14,0x09,0x08,0x09,0x14,0x49,0x22,0x29,0xC2,0x08,0x01,0x00,0x01,0x00,0x00},/*"发",16*/

};



void DisplayChinese_DrawChar16x16(uint16_t x, uint16_t y, const unsigned char font[DISPLAY_CHINESE_BYTES], uint16_t color, uint16_t bgColor)
{
    uint8_t row;
    uint8_t col;

    if (font == NULL) {
        return;
    }

    for (col = 0U; col < DISPLAY_CHINESE_WIDTH; col++) {
        uint16_t colData = ((uint16_t)font[col * 2U] << 8) | font[col * 2U + 1U];
        for (row = 0U; row < DISPLAY_CHINESE_HEIGHT; row++) {
            uint16_t pixelColor = ((colData & (0x8000U >> row)) != 0U) ? color : bgColor;
            ST7735_FillRect((uint16_t)(x + col), (uint16_t)(y + row), 1U, 1U, pixelColor);
        }
    }
}

void DisplayChinese_DrawChar16x16Transparent(uint16_t x, uint16_t y, const unsigned char font[DISPLAY_CHINESE_BYTES], uint16_t color)
{
    uint8_t row;
    uint8_t col;

    if (font == NULL) {
        return;
    }

    for (col = 0U; col < DISPLAY_CHINESE_WIDTH; col++) {
        uint16_t colData = ((uint16_t)font[col * 2U] << 8) | font[col * 2U + 1U];
        for (row = 0U; row < DISPLAY_CHINESE_HEIGHT; row++) {
            if ((colData & (0x8000U >> row)) != 0U) {
                ST7735_FillRect((uint16_t)(x + col), (uint16_t)(y + row), 1U, 1U, color);
            }
        }
    }
}

void DisplayChinese_DrawWorkCardTitle(uint16_t x, uint16_t y, uint16_t color, uint16_t bgColor)
{
    uint8_t index;

    for (index = 0U; index < DISPLAY_CHINESE_TITLE_COUNT; index++) {
        DisplayChinese_DrawChar16x16((uint16_t)(x + index * DISPLAY_CHINESE_WIDTH), y, ling[index], color, bgColor);
    }
}

void DisplayChinese_DrawWorkCardTitleTransparent(uint16_t x, uint16_t y, uint16_t color)
{
    uint8_t index;

    for (index = 0U; index < DISPLAY_CHINESE_TITLE_COUNT; index++) {
        DisplayChinese_DrawChar16x16Transparent((uint16_t)(x + index * DISPLAY_CHINESE_WIDTH), y, ling[index], color);
    }
}

static void DisplayChinese_DrawColon16x16(uint16_t x, uint16_t y, uint16_t color, uint16_t bgColor)
{
    ST7735_FillRect(x, y, DISPLAY_CHINESE_WIDTH, DISPLAY_CHINESE_HEIGHT, bgColor);
    ST7735_FillRect((uint16_t)(x + 6U), (uint16_t)(y + 4U), 3U, 3U, color);
    ST7735_FillRect((uint16_t)(x + 6U), (uint16_t)(y + 10U), 3U, 3U, color);
}

static void DisplayChinese_DrawColon16x16Transparent(uint16_t x, uint16_t y, uint16_t color)
{
    ST7735_FillRect((uint16_t)(x + 6U), (uint16_t)(y + 4U), 3U, 3U, color);
    ST7735_FillRect((uint16_t)(x + 6U), (uint16_t)(y + 10U), 3U, 3U, color);
}

static void DisplayChinese_DrawSequence(uint16_t x, uint16_t y, const uint8_t *indices, uint8_t count, uint16_t color, uint16_t bgColor)
{
    uint8_t index;

    for (index = 0U; index < count; index++) {
        uint16_t drawX = (uint16_t)(x + index * DISPLAY_CHINESE_WIDTH);
        if (indices[index] == 0xFFU) {
            DisplayChinese_DrawColon16x16(drawX, y, color, bgColor);
        } else if (indices[index] < DISPLAY_CHINESE_COUNT) {
            DisplayChinese_DrawChar16x16(drawX, y, ling[indices[index]], color, bgColor);
        }
    }
}

static void DisplayChinese_DrawSequenceTransparent(uint16_t x, uint16_t y, const uint8_t *indices, uint8_t count, uint16_t color)
{
    uint8_t index;

    for (index = 0U; index < count; index++) {
        uint16_t drawX = (uint16_t)(x + index * DISPLAY_CHINESE_WIDTH);
        if (indices[index] == 0xFFU) {
            DisplayChinese_DrawColon16x16Transparent(drawX, y, color);
        } else if (indices[index] < DISPLAY_CHINESE_COUNT) {
            DisplayChinese_DrawChar16x16Transparent(drawX, y, ling[indices[index]], color);
        }
    }
}

void DisplayChinese_DrawWorkCardInfo(uint16_t x, uint16_t y, uint16_t color, uint16_t bgColor)
{
    static const uint8_t nameLine[] = {8U, 9U, 0xFFU, 0U, 14U, 1U};
    static const uint8_t jobLine[] = {10U, 11U, 0xFFU, 15U, 16U, 17U, 18U, 19U};
    static const uint8_t deptLine[] = {12U, 13U, 0xFFU, 20U, 21U, 22U, 23U, 24U};

    DisplayChinese_DrawSequence(x, y, nameLine, (uint8_t)(sizeof(nameLine) / sizeof(nameLine[0])), color, bgColor);
    DisplayChinese_DrawSequence(x, (uint16_t)(y + 16U), jobLine, (uint8_t)(sizeof(jobLine) / sizeof(jobLine[0])), color, bgColor);
    DisplayChinese_DrawSequence(x, (uint16_t)(y + 32U), deptLine, (uint8_t)(sizeof(deptLine) / sizeof(deptLine[0])), color, bgColor);
}

void DisplayChinese_DrawWorkCardInfoTransparent(uint16_t x, uint16_t y, uint16_t color)
{
    static const uint8_t nameLine[] = {8U, 9U, 0xFFU, 0U, 14U, 1U};
    static const uint8_t jobLine[] = {10U, 11U, 0xFFU, 15U, 16U, 17U, 18U, 19U};
    static const uint8_t deptLine[] = {12U, 13U, 0xFFU, 20U, 21U, 22U, 23U, 24U};

    DisplayChinese_DrawSequenceTransparent(x, y, nameLine, (uint8_t)(sizeof(nameLine) / sizeof(nameLine[0])), color);
    DisplayChinese_DrawSequenceTransparent(x, (uint16_t)(y + 16U), jobLine, (uint8_t)(sizeof(jobLine) / sizeof(jobLine[0])), color);
    DisplayChinese_DrawSequenceTransparent(x, (uint16_t)(y + 32U), deptLine, (uint8_t)(sizeof(deptLine) / sizeof(deptLine[0])), color);
}


